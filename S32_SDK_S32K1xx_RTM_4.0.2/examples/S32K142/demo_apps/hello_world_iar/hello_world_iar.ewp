# IAR project hello_world_iar.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.OGChipSelectEditMenu: S32K142 NXP S32K142
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K142
  ICCARM.IExtraOptions: --debug; --no_wrap_diagnostics
  ICCARM.CCIncludePath2: ..\..\..\..\platform\devices; ..\..\..\..\platform\devices\common; ..\..\..\..\platform\drivers\inc; ..\..\..\..\platform\devices\S32K142\include; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hello_world_IAR.srec
  ILINK.IlinkOutputFile: hello_world_IAR.elf
  ILINK.IlinkIcfFile: ..\..\..\..\platform\devices\S32K142\linker\iar\S32K142_32_ram.icf
  ILINK.IlinkExtraOptions: --no_wrap_diagnostics
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\platform\drivers\inc; ..\..\..\..\platform\devices; ..\..\..\..\platform\devices\common; ..\..\..\..\platform\devices\S32K142\include; src
  ILINK.IlinkIcfFile: ..\..\..\..\platform\devices\S32K142\linker\iar\S32K142_32_flash.icf
  ILINK.IlinkExtraOptions: --no_wrap_diagnostics; --no_library_search
  group platform/devices
    ../../../../platform/devices/: device_registers.h startup.c startup.h
  group platform/devices/common
    ../../../../platform/devices/common/: s32_core_cm4.h
  group platform/devices/S32K142
    ../../../../platform/devices/S32K142/: S32K142.svd
  group platform/devices/S32K142/include
    ../../../../platform/devices/S32K142/include/: S32K142.h S32K142_features.h
  group platform/devices/S32K142/linker/iar
    ../../../../platform/devices/S32K142/linker/iar/: S32K142_32_flash.icf S32K142_32_ram.icf
  group platform/devices/S32K142/startup
    ../../../../platform/devices/S32K142/startup/: system_S32K142.c system_S32K142.h
  group platform/devices/S32K142/startup/iar
    ../../../../platform/devices/S32K142/startup/iar/: startup_S32K142.s
  group platform/drivers/inc
    ../../../../platform/drivers/inc/: clock_manager.h interrupt_manager.h pins_driver.h
  group platform/drivers/src/clock/S32K1xx
    ../../../../platform/drivers/src/clock/S32K1xx/: clock_S32K1xx.c clock_S32K1xx.h
  group platform/drivers/src/interrupt
    ../../../../platform/drivers/src/interrupt/: interrupt_manager.c
  group platform/drivers/src/pins
    ../../../../platform/drivers/src/pins/: pins_driver.c pins_port_hw_access.c
  group src
    src/: main.c
